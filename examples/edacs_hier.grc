options:
  parameters:
    category: '[EDACS]'
    generate_options: hb
    id: trunked_radio_hier
    output_language: python
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: fp_sel_index
  id: variable_function_probe
  parameters:
    block_id: edacs_handle_eot_0
    function_name: get_sel_index
    poll_rate: '100'
    value: '0'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: sink_rate / baud_rate
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: source_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: source_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1024'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1-fp_sel_index
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_not_xx_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: center_freq
  id: parameter
  parameters:
    label: Center Frequency
    value: '867.4105'
  states: {}
- name: digital_correlate_access_code_bb_0
  id: digital_correlate_access_code_bb
  parameters:
    access_code: '010101010101010101010111000100100101010101010101'
    threshold: '0'
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: int(samp_per_sym)
    sensitivity: '1.0'
  states: {}
- name: dsd_block_ff_0
  id: dsd_block_ff
  parameters:
    errorbars: 'False'
    frame: dsd.dsd_FRAME_PROVOICE
    mod: dsd.dsd_MOD_AUTO_SELECT
    uvquality: '3'
    verbosity: '3'
  states: {}
- name: edacs_find_chan_nums_0
  id: edacs_find_chan_nums
  parameters:
    center_freq: center_freq
    freq_list: freq_list
    samp_rate: source_rate
    threshold: voice_threshold
  states: {}
- name: edacs_handle_eot_0
  id: edacs_handle_eot
  parameters:
    alias: edacs_handle_eot
    noise_threshold: noise_threshold
    samp_rate: sink_rate
    tone_freq: '4800'
    tone_threshold: tone_threshold
  states: {}
- name: edacs_proc_msg_0
  id: edacs_proc_msg
  parameters:
    analog: track_analog
    center_freq: center_freq
    digital: track_digital
    find_lcns: find_chan_nums
    freq_list: freq_list
    talkgroup: talkgroup
  states: {}
- name: find_chan_nums
  id: parameter
  parameters:
    label: Find Channel Numbers
    value: 'False'
  states: {}
- name: freq_list
  id: parameter
  parameters:
    label: Frequency List
    value: '[866.0375, 866.2875, 866.5375, 866.7875, 867.0375, 867.2875, 867.5375, 867.7875, 868.0375, 868.2875, 868.5375, 868.7875, 866.0625, 866.3125, 866.5625, 866.8125, 867.0625, 867.3125, 867.5625, 867.8125]'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: .00625e6
    decim: '100'
    gain: '1'
    samp_rate: source_rate
    type: fir_filter_ccf
    width: .002e6
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: .00625e6
    decim: '100'
    gain: '1'
    samp_rate: source_rate
    type: fir_filter_ccf
    width: .002e6
    win: firdes.WIN_HAMMING
  states: {}
- name: noise_threshold
  id: parameter
  parameters:
    label: Noise Threshold
    value: '5'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: Audio Out
    type: float
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: ASCII Out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: IQ In
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(source_rate / 100000)
    interp: int(sink_rate / 1000)
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(source_rate / 100000)
    interp: int(sink_rate / 1000)
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(sink_rate / 8000)
    taps: ''
    type: fff
  states: {}
- name: sink_rate
  id: parameter
  parameters:
    label: Sink Sample Rate
    value: '48000'
  states: {}
- name: source_rate
  id: parameter
  parameters:
    label: Source Sample Rate
    value: '4000000'
  states: {}
- name: talkgroup
  id: parameter
  parameters:
    label: Talkgroup
    value: '1796'
  states: {}
- name: tone_threshold
  id: parameter
  parameters:
    label: Tone Threshold
    value: '0.1'
  states: {}
- name: track_analog
  id: parameter
  parameters:
    label: Track Analog
    value: 'True'
  states: {}
- name: track_digital
  id: parameter
  parameters:
    label: Track Digital
    value: 'True'
  states: {}
- name: voice_threshold
  id: parameter
  parameters:
    label: Voice Threshold
    value: '0.4'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', edacs_handle_eot_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1, '1']
- [blocks_add_xx_0, '0', pad_sink_0, '0']
- [blocks_delay_0, '0', edacs_find_chan_nums_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_1, '0', low_pass_filter_0_0, '0']
- [blocks_not_xx_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_not_xx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_bb_0, '0']
- [digital_correlate_access_code_bb_0, '0', edacs_proc_msg_0, '0']
- [digital_gfsk_demod_0, '0', blocks_pack_k_bits_bb_0, '0']
- [dsd_block_ff_0, '0', rational_resampler_xxx_1, '0']
- [edacs_find_chan_nums_0, status_out, edacs_proc_msg_0, chan_status_in]
- [edacs_handle_eot_0, '0', blocks_multiply_const_vxx_0, '0']
- [edacs_handle_eot_0, '0', dsd_block_ff_0, '0']
- [edacs_handle_eot_0, status_out, edacs_proc_msg_0, eot_status_in]
- [edacs_proc_msg_0, '0', pad_sink_1, '0']
- [edacs_proc_msg_0, chan_status_out, edacs_find_chan_nums_0, status_in]
- [edacs_proc_msg_0, ctrl_freq, analog_sig_source_x_0, freq]
- [edacs_proc_msg_0, eot_status_out, edacs_handle_eot_0, status_in]
- [edacs_proc_msg_0, voice_freq, analog_sig_source_x_1, freq]
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_0_0, '0']
- [pad_source_0, '0', blocks_delay_0, '0']
- [pad_source_0, '0', blocks_multiply_xx_0, '0']
- [pad_source_0, '0', blocks_multiply_xx_1, '0']
- [rational_resampler_xxx_0, '0', digital_gfsk_demod_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_1, '0', blocks_add_xx_0, '1']

metadata:
  file_format: 1
