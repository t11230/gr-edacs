options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '852.4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: slider_noise_threshold
  id: variable_qtgui_range
  parameters:
    label: Noise Threshold
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '50'
    value: '5'
  states: {}
- name: slider_tone_threshold
  id: variable_qtgui_range
  parameters:
    label: EOT Tone Threshold
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '5'
    value: '0.15'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/user/DevStuff/gr-edacs/sample.iq
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '6777'
    psize: '1472'
    type: byte
    vlen: '1'
  states: {}
- name: note_0
  id: note
  parameters:
    note: Enable the TCP Sink block and listen on localhost, port 8080 (nc -l -p 8080) for all message output
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: bladerf
    bb_gain0: '20'
    freq0: 851e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: '4000000'
    sync: sync
    type: fc32
  states: {state: disabled}
- name: trunked_radio_0
  id: trunked_radio
  parameters:
    center_freq: '867.4125'
    find_chan_nums: 'False'
    freq_list: '[866.0375, 866.2875, 866.5375, 866.7875, 867.0375, 867.2875, 867.5375, 867.7875, 868.0375, 868.2875, 868.5375, 868.7875, 866.0625, 866.3125, 866.5625, 866.8125, 867.0625, 867.3125, 867.5625, 867.8125]'
    noise_threshold: slider_noise_threshold
    sink_rate: '48000'
    source_rate: '4000000'
    talkgroup: '0'
    tone_threshold: slider_tone_threshold
    track_analog: 'True'
    track_digital: 'True'
    voice_threshold: '0.1'
  states: {state: disabled}
- name: trunked_radio_hier_0
  id: trunked_radio_hier
  parameters:
    center_freq: center_freq
    find_chan_nums: 'False'
    freq_list: '[851.150, 851.5375, 852.1375, 852.5375, 852.7875, 853.1375, 853.5875, 851.175, 851.900, 852.3125, 852.5875, 852.8125, 853.5375, 853.8125, 851.400, 852.0375, 852.3625, 852.6125, 853.1125, 853.5625]'
    noise_threshold: '5'
    sink_rate: '48000'
    source_rate: samp_rate
    talkgroup: '0'
    tone_threshold: '0.1'
    track_analog: 'True'
    track_digital: 'True'
    voice_threshold: '0.4'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', trunked_radio_hier_0, '0']
- [osmosdr_source_0, '0', trunked_radio_0, '0']
- [trunked_radio_0, '0', audio_sink_0_0, '0']
- [trunked_radio_0, '0', blocks_null_sink_1, '0']
- [trunked_radio_0, '1', blocks_null_sink_0, '0']
- [trunked_radio_hier_0, '0', audio_sink_0_0, '0']
- [trunked_radio_hier_0, '1', blocks_udp_sink_0, '0']

metadata:
  file_format: 1
